Commit message: 4月10日

File: chapt6/chapt6_ws/src/fishbot_description/urdf/first_robot.urdf (robot description, URDF)
Before this commit: robot first_robot, 2 links, 0 joints
Links:
- link imu_link: geometry visual box size=2.0 2.0 2.0
